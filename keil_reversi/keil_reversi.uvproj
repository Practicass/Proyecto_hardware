# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: main.c temporizador_hal.c temporizador_hal.h temporizador_drv.c temporizador_drv.h gpio_hal.h fifo.c io_reserva.h hello_world.c planificador.c hello_world.h power.c power.h alarmas.c alarmas.h int_externas_hal.c int_externas_hal.h botones.c botones.h planificador.h fifo.h juego.c juego.h visualizar.c visualizar.h test.c test.h planificador_test_alarmas.c planificador_test_alarmas.h SWI.s SWI.h wd_hal.c wd_hal.h linea_serie_hal.c linea_serie_hal.h linea_serie_drv.c linea_serie_drv.h conecta_K_mod.c conecta_K_mod.h tablero.c tablero.h celda.h config_conecta_K.h
